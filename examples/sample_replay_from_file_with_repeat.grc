options:
  parameters:
    generate_options: qt_gui
    id: sample_replay_from_file_with_repeat
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    type: real
    value: 162.425e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Change this.
      The others are radio_freq is calculated
      based on tuning offset
    value: 1691e6
  states: {state: disabled}
- name: file_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: lna_gain
  id: variable
  parameters:
    comment: |-
      Hackrf:
      RX: 0-40 in 8 dB steps
      TX: 0-47 in 1 dB steps
    value: '15'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: file_rate
  states: {}
- name: tuning_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: vga_gain
  id: variable
  parameters:
    comment: |-
      Hackrf:
      RX: 0-62 in 2 dB steps
      TX: N/A
    value: '15'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Offset tuning
    freq: '-1.0*tuning_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: filerepeater_file_repeater_ex_0
  id: filerepeater_file_repeater_ex
  parameters:
    complexconv: '0'
    delayFirstStart: '2.0'
    file: /opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_NoFilter.iq
    repeat: 'True'
    repeat_delay: '2000'
    repeat_times: '0'
    type: complex
    verbose: 'False'
    vlen: '1'
  states: {}
- name: note_1
  id: note
  parameters:
    note: Set file before running
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 2,0,2,1
    name: '"File Spectrum"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq+tuning_offset
    fftsize: '1024'
    gui_hint: 2,2,2,1
    name: '"Transmitted Spectrum"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq+tuning_offset
    fftsize: '1024'
    gui_hint: 4,0,2,4
    int_min: '-80'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_mute_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_mute_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [filerepeater_file_repeater_ex_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
