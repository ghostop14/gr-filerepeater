options:
  parameters:
    generate_options: qt_gui
    id: test_state_or
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Just needed for scheduling engine timing
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: filerepeater_StateOr_0
  id: filerepeater_StateOr
  parameters: {}
  states: {}
- name: filerepeater_StateTimer_0
  id: filerepeater_StateTimer
  parameters:
    cycleTime: '10.0'
    delayBeforeStart: '0.0'
    triggerTime: '5.0'
  states: {}
- name: filerepeater_TimeOfDay_0
  id: filerepeater_TimeOfDay
  parameters:
    hours: '15'
    minutes: '48'
    seconds: '00'
    triggerTime: '300.0'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [filerepeater_StateOr_0, state, blocks_message_debug_0, print]
- [filerepeater_StateTimer_0, trigger, filerepeater_StateOr_0, state1]
- [filerepeater_TimeOfDay_0, trigger, filerepeater_StateOr_0, state2]

metadata:
  file_format: 1
