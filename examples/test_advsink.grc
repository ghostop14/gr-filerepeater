options:
  parameters:
    generate_options: qt_gui
    id: top_advsink
    output_language: python
  states: {}

blocks:
- name: host
  id: variable
  parameters:
    comment: |-
      139 is rpisigint
      147 is rpisigint2
      99 sigintwifi
    value: '''192.168.254.147'''
  states: {}
- name: lna_gain
  id: variable
  parameters:
    value: '12'
  states: {}
- name: radio_freq
  id: variable
  parameters:
    value: 162.425e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: src_spyserver
  id: variable
  parameters:
    value: '''host=''+host+'',port=5555,spyserver=0'''
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /tmp
    basefile: sink_test
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: radio_freq
    recordOnStart: 'True'
    sampleRate: samp_rate
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_StateOr_0
  id: filerepeater_StateOr
  parameters: {}
  states: {state: disabled}
- name: filerepeater_StateTimer_0
  id: filerepeater_StateTimer
  parameters:
    cycleTime: '30.0'
    delayBeforeStart: '0.0'
    triggerTime: '15.0'
  states: {state: disabled}
- name: filerepeater_TimeOfDay_0
  id: filerepeater_TimeOfDay
  parameters:
    hours: '9'
    minutes: '2'
    seconds: '00'
    triggerTime: '300.0'
  states: {state: disabled}
- name: osmosdr_source_0_1_1
  id: osmosdr_source
  parameters:
    args: rtl
    bb_gain0: '0'
    comment: Airspy Config
    dc_offset_mode0: '2'
    freq0: radio_freq
    gain0: lna_gain
    gain_mode0: 'True'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [filerepeater_StateOr_0, state, filerepeater_AdvFileSink_0, recordstate]
- [filerepeater_StateTimer_0, trigger, filerepeater_StateOr_0, state1]
- [filerepeater_TimeOfDay_0, trigger, filerepeater_StateOr_0, state2]
- [osmosdr_source_0_1_1, '0', filerepeater_AdvFileSink_0, '0']

metadata:
  file_format: 1
