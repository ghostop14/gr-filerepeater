options:
  parameters:
    generate_options: qt_gui
    id: test_timeofday
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Just needed for scheduling engine timing
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: filerepeater_TimeOfDay_0
  id: filerepeater_TimeOfDay
  parameters:
    hours: '15'
    minutes: '47'
    seconds: '00'
    triggerTime: '10.0'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [filerepeater_TimeOfDay_0, trigger, blocks_message_debug_0, print]

metadata:
  file_format: 1
