<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_state_and</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Just needed for scheduling engine timing</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>filerepeater_StateAnd</key>
<param><key>id</key><value>filerepeater_StateAnd_0</value></param>
</block>
<block>
<key>filerepeater_StateTimer</key>
<param><key>id</key><value>filerepeater_StateTimer_0</value></param>
<param><key>cycleTime</key><value>10.0</value></param>
<param><key>delayBeforeStart</key><value>0.0</value></param>
<param><key>triggerTime</key><value>5.0</value></param>
</block>
<block>
<key>filerepeater_TimeOfDay</key>
<param><key>id</key><value>filerepeater_TimeOfDay_0</value></param>
<param><key>triggerTime</key><value>300.0</value></param>
<param><key>hours</key><value>20</value></param>
<param><key>minutes</key><value>15</value></param>
<param><key>seconds</key><value>00</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>state</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>filerepeater_StateTimer_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>trigger</source_key><sink_key>state1</sink_key></connection>
<connection><source_block_id>filerepeater_TimeOfDay_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>trigger</source_key><sink_key>state2</sink_key></connection>
</flow_graph>
